# Keil uVision project led.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\core;..\Library\inc;..\System\Encoder;..\System\Systick;..\System\Usart;..\Hardware\LED;..\Application\inc;..\Hardware\SYN7318
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: stm32f10x_it.c system_stm32f10x.c
    ../Application/src/: main.c
  group Application
    ../Application/src/: pidctrller.c comHandle.c
  group Hardware
    ../HARDWARE/LED/: LED.c
    ../Hardware/SYN7318/: syn7318.c
  group System
    ../System/Encoder/: encoder.c
    ../System/Systick/: systick.c
    ../System/Usart/: usart.c
  group Library
    ../Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
